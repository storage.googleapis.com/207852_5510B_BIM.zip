Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-01-31T08:11:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 31 08:11:35 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{03480346-91B0-45D6-8665-F2AB410231F6}\ifc * Database version: 5507 * Database creation date: Wed Jan 31 08:11:34 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 31 08:11:34 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 31 08:11:34 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowController: 5510B Washbasin faucet, 5510B:5510B Washbasin faucet:330788
In: Level 1
Type - PredefinedType: FAUCET; Material: Copper
Pset_ManufacturerTypeInformation - ModelReference: 5510B; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5510B Washbasin faucet
